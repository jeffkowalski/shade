options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    comment: inverse of the symbol width
    value: int(1.0/symbol_width)
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 433.42e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baud)
  states: {}
- name: symbol_width
  id: variable
  parameters:
    value: '642e-6'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/raw.dat
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: sps
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      Remember, each "byte" on screen is actually
      a bit!
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '.150'
    init: '0'
    low: '.05'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: cutoff*2
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    tr_level: '-50.0'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.02'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Source
    label2: Thresh,,ZC
    name: Signal
    nconnections: '2'
    size: int(samp_rate/5)
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"trigger"'
    type: float
    ymax: '2'
    ymin: '-.2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Decimated
    label2: Synced
    marker1: '3'
    marker2: '4'
    name: Symbols
    nconnections: '2'
    size: int(baud)
    srate: int(baud)
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2'
    ymin: '-.2'
  states: {}
- name: reveng_pattern_dump_0
  id: reveng_pattern_dump
  parameters:
    dump_len: '112'
    file_name: ''
    output_fmt: '%[bits]'
    pattern: '[1]*4 + [0]*4 + [1]*4 + [0]*4 + [1]*7 + [0]'
    rel_time: 'False'
    stdout: 'False'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '48'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_add_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_threshold_ff_0, '0', blocks_add_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_char_to_float_0_1, '0']
- [digital_binary_slicer_fb_0_0, '0', reveng_pattern_dump_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [low_pass_filter_1, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0, '0']
- [reveng_pattern_dump_0, out, blocks_message_debug_0, print]
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_1, '0']

metadata:
  file_format: 1
